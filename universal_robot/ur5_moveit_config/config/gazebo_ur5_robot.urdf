Commit message: Array of poses Middle and Close

File: universal_robot/ur5_moveit_config/config/gazebo_ur5_robot.urdf (robot description, URDF)
Before this commit: robot ur5_robot, 18 links, 17 joints
Links:
- link camera_link: mass 0.01 -> 0.1
